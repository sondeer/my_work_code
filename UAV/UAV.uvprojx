# Keil uVision project UAV.uvprojx, settings and files
target YunTaiFreeRTOS (ARM-ADS)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YunTai
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: .\Inc;.\Middlewares\Third_Party\FreeRTOS\Source\include;.\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/Src/: main.cpp stm32f4xx_it.cpp AttitudeCalculationEKF.cpp AttitudeControl.cpp CalculationPID.cpp RcCtrl.cpp ModeCtrl.cpp PositionCalculation.cpp
  group Driver
    ./Driver/Src/: led.cpp SPI.cpp HMC5983.cpp MS5611.cpp LSM6DS33.cpp Motor.cpp Sbus.cpp Power.cpp ExIMU.cpp OnChipFlash.cpp
    ./Driver/Src/Usb/: usb_device.c usbd_conf.c usbd_custom_hid_if.c usbd_desc.c
  group UsbLib
    ./Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
target UAV (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: UAV +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: ARM_MATH_CM4
  c include: .\Driver\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc;.\User\Inc;.\Driver\Inc\Usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.80.0, Device:STM32Cube Framework:Classic 1.3.1, Device:STM32Cube HAL:ADC 1.3.1, Device:STM32Cube HAL:Common 1.3.1, Device:STM32Cube HAL:Cortex 1.3.1, Device:STM32Cube HAL:DMA 1.3.1, Device:STM32Cube HAL:Flash 1.3.1, Device:STM32Cube HAL:GPIO 1.3.1, Device:STM32Cube HAL:I2C 1.3.1, Device:STM32Cube HAL:PCD 1.3.1, Device:STM32Cube HAL:PWR 1.3.1, Device:STM32Cube HAL:RCC 1.3.1, Device:STM32Cube HAL:SPI 1.3.1, Device:STM32Cube HAL:TIM 1.3.1, Device:STM32Cube HAL:UART 1.3.1, Device:Startup 2.3.1
